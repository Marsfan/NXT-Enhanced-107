# IAR project LMS_ARM.ewp, settings and files
configuration RAM_Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S64 Atmel AT91SAM7S64
  ICCARM.CCDefines: ESS
  ICCARM.CCIncludePath2: srciar\; ..\..\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.AUserIncludes: srciar\; ..\..\include\
  XLINK.XclFile: at91SAM7S64_16KRAM.xcl
configuration Flash Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: ..\Lib\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: PROTOTYPE_PCB_4; NEW_MENU
  ICCARM.CCIncludePath2: ..\..\; ..\Include\
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: at91SAM7S256_Remap.xcl
configuration Bin Output (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: ..\Lib\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: PROTOTYPE_PCB_4; NEW_MENU
  ICCARM.CCIncludePath2: ..\..\; ..\Include\
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: at91SAM7S256_Remap.xcl
configuration Benchmark (ARM)
  as the first configuration, except:
  General.RTConfigPath: ..\Lib\dl4tptinl8n.h
  General.OGChipSelectEditMenu: AT91SAM7S256 Atmel AT91SAM7S256
  ICCARM.CCDefines: PROTOTYPE_PCB_4; NEW_MENU; VM_BENCHMARK
  ICCARM.CCIncludePath2: ..\..\; ..\Include\
  AARM.AUserIncludes: ..\..\include\
  XLINK.XclFile: at91SAM7S256_Remap.xcl
  group (top)
    ../../Source/: c_button.c c_cmd.c c_comm.c c_display.c c_input.c c_ioctrl.c c_loader.c c_lowspeed.c c_output.c c_sound.c c_ui.c d_bt.c d_button.c d_display.c d_hispeed.c d_input.c d_ioctrl.c d_loader.c d_lowspeed.c d_output.c d_sound.c d_timer.c d_usb.c Functions.inl m_sched.c
    ../Include/: Cstartup.s79 Cstartup_SAM7.c
